* Functional test stimulus file for 10ns period

* TT process corner
.include "/home/dareminion/anaconda3/envs/mem/lib/python3.13/site-packages/openram/technology/scn4m_subm/models/nom/pmos.sp"
.include "/home/dareminion/anaconda3/envs/mem/lib/python3.13/site-packages/openram/technology/scn4m_subm/models/nom/nmos.sp"
.include "/tmp/openram_dareminion_27216_temp/sram.sp"

* Global Power Supplies
Vvdd vdd 0 3.3

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
XRAM_Mem din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 a0_0 a0_1 a0_2 a0_3 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 vdd gnd RAM_Mem

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f

* Important signals for debug
* bl:	xsram:xbank0:bl_0_0
* br:	xsram:xbank0:br_0_0
* s_en:	xsram:s_en
* q:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q
* qbar:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 11111111  to  address 1110 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 10000011  to  address 1110 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 01010110  to  address 1110 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 01010110 from address 1110 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 01010110 from address 1110 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 01010110 from address 1110 (from port 0) during cycle 6 (60ns - 70ns)
*	Writing 11000010  to  address 1110 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 9 (90ns - 100ns)
*	Writing 01101001  to  address 1110 (from port 0) during cycle 10 (100ns - 110ns)
*	Writing 11011010  to  address 1110 (from port 0) during cycle 11 (110ns - 120ns)
*	Reading 11011010 from address 1110 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 11011110  to  address 0000 (from port 0) during cycle 13 (130ns - 140ns)
*	Reading 11011110 from address 0000 (from port 0) during cycle 14 (140ns - 150ns)
*	Writing 01011110  to  address 1110 (from port 0) during cycle 15 (150ns - 160ns)
*	Writing 00010110  to  address 1110 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 11011110 from address 0000 (from port 0) during cycle 17 (170ns - 180ns)
*	Reading 00010110 from address 1110 (from port 0) during cycle 18 (180ns - 190ns)
*	Writing 01101110  to  address 1110 (from port 0) during cycle 19 (190ns - 200ns)
*	Writing 01000111  to  address 1110 (from port 0) during cycle 20 (200ns - 210ns)
*	Writing 01001111  to  address 0000 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 01001111 from address 0000 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing 11010101  to  address 1110 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 11010101 from address 1110 (from port 0) during cycle 25 (250ns - 260ns)
*	Writing 01010111  to  address 1110 (from port 0) during cycle 27 (270ns - 280ns)
*	Reading 01001111 from address 0000 (from port 0) during cycle 30 (300ns - 310ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 01001111 from address 0000 (from port 0) during cycle 32 (320ns - 330ns)
*	Writing 00111100  to  address 0000 (from port 0) during cycle 33 (330ns - 340ns)
*	Writing 10011000  to  address 0000 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 10011000 from address 0000 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 10011000 from address 0000 (from port 0) during cycle 36 (360ns - 370ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 37 (370ns - 380ns)
*	Writing 00000111  to  address 0000 (from port 0) during cycle 38 (380ns - 390ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 39 (390ns - 400ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 40 (400ns - 410ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 43 (430ns - 440ns)
*	Writing 00011011  to  address 1110 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 45 (450ns - 460ns)
*	Writing 00110001  to  address 1110 (from port 0) during cycle 46 (460ns - 470ns)
*	Writing 10100110  to  address 1110 (from port 0) during cycle 47 (470ns - 480ns)
*	Writing 10101111  to  address 1110 (from port 0) during cycle 48 (480ns - 490ns)
*	Writing 11010111  to  address 1110 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 11010111 from address 1110 (from port 0) during cycle 51 (510ns - 520ns)
*	Writing 01000011  to  address 1110 (from port 0) during cycle 52 (520ns - 530ns)
*	Reading 00000111 from address 0000 (from port 0) during cycle 53 (530ns - 540ns)
*	Reading 01000011 from address 1110 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 01000011 from address 1110 (from port 0) during cycle 55 (550ns - 560ns)
*	Reading 01000011 from address 1110 (from port 0) during cycle 56 (560ns - 570ns)
*	Reading 01000011 from address 1110 (from port 0) during cycle 57 (570ns - 580ns)
*	Writing 01100111  to  address 0000 (from port 0) during cycle 58 (580ns - 590ns)
*	Writing 01011101  to  address 1110 (from port 0) during cycle 59 (590ns - 600ns)
*	Writing 10100110  to  address 0000 (from port 0) during cycle 61 (610ns - 620ns)
*	Reading 10100110 from address 0000 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 01011101 from address 1110 (from port 0) during cycle 63 (630ns - 640ns)
*	Writing 00011010  to  address 1110 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 10100110 from address 0000 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 71 (710ns - 720ns)
*	Writing 11001100  to  address 0000 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 11001100 from address 0000 (from port 0) during cycle 79 (790ns - 800ns)
*	Reading 11001100 from address 0000 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 11001100 from address 0000 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 86 (860ns - 870ns)
*	Writing 10011010  to  address 0000 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 10011010 from address 0000 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 10011010 from address 0000 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 10011010 from address 0000 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 00011010 from address 1110 (from port 0) during cycle 93 (930ns - 940ns)
*	Writing 11000100  to  address 0000 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 11000100 from address 0000 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 11000100 from address 0000 (from port 0) during cycle 97 (970ns - 980ns)
*	Writing 00001001  to  address 1110 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 00001001 from address 1110 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 00001001 from address 1110 (from port 0) during cycle 100 (1000ns - 1010ns)
*	Writing 01101000  to  address 1110 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Writing 01100111  to  address 1110 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Writing 01000111  to  address 1110 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 01000111 from address 1110 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Reading 01000111 from address 1110 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 01000111 from address 1110 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Reading 11000100 from address 0000 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Writing 00111011  to  address 1110 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 11000100 from address 0000 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 00111011 from address 1110 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 11000100 from address 0000 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Reading 00111011 from address 1110 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Writing 01101010  to  address 1110 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Writing 11000100  to  address 1110 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 11000100 from address 1110 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Writing 01101010  to  address 1110 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Reading 11000100 from address 0000 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Writing 11000011  to  address 0000 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 11000011 from address 0000 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 11000011 from address 0000 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Writing 10101100  to  address 1110 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Writing 10000100  to  address 1110 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Writing 11010010  to  address 1110 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Writing 00001110  to  address 1110 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Writing 10101100  to  address 1110 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Reading 11000011 from address 0000 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Reading 10101100 from address 1110 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Reading 11000011 from address 0000 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 11000011 from address 0000 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Reading 11000011 from address 0000 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Reading 10101100 from address 1110 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 10101100 from address 1110 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Writing 00100011  to  address 0000 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 00100011 from address 0000 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 10101100 from address 1110 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 10101100 from address 1110 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Reading 10101100 from address 1110 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Writing 00100000  to  address 1110 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 00100011 from address 0000 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 00100011 from address 0000 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Reading 00100011 from address 0000 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Reading 00100011 from address 0000 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Writing 00001001  to  address 1110 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Writing 11110110  to  address 1110 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Writing 00001011  to  address 0000 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Writing 11110111  to  address 0000 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 11110110 from address 1110 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Writing 01011111  to  address 0000 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Reading 11110110 from address 1110 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Reading 11110110 from address 1110 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Writing 10000010  to  address 1110 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Reading 01011111 from address 0000 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing 01101100  to  address 0000 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Writing 00000110  to  address 1110 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 00000110 from address 1110 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 01101100 from address 0000 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 01101100 from address 0000 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 01101100 from address 0000 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 00000110 from address 1110 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Reading 00000110 from address 1110 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Reading 01101100 from address 0000 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Writing 11000000  to  address 1110 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 01101100 from address 0000 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Reading 11000000 from address 1110 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Reading 01101100 from address 0000 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 0.0v 479.45n 0.0v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 3.3v 489.45n 3.3v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 3.3v 589.45n 3.3v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 0), (2030, 1), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 0.0v 179.45n 0.0v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 0.0v 539.45n 0.0v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 0.0v 589.45n 0.0v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 3.3v 789.45n 3.3v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 0), (2030, 1), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 0.0v 179.45n 0.0v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 0.0v 539.45n 0.0v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 0.0v 589.45n 0.0v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 3.3v 789.45n 3.3v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 0), (2030, 1), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 0.0v 179.45n 0.0v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 0.0v 539.45n 0.0v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 0.0v 589.45n 0.0v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 3.3v 789.45n 3.3v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 0), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 3.3v 9.45n 3.3v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 3.3v 229.45n 3.3v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 3.3v 269.45n 3.3v 269.55n 0.0v 279.45n 0.0v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 3.3v 699.45n 3.3v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 0.0v 829.45n 0.0v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 3.3v 959.45n 3.3v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 3.3v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 0), (110, 0), (120, 1), (130, 0), (140, 1), (150, 0), (160, 0), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 1), (630, 1), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 3.3v 9.45n 3.3v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 3.3v 129.45n 3.3v 129.55n 0.0v 139.45n 0.0v 139.55n 3.3v 149.45n 3.3v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 0.0v 279.45n 0.0v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 0.0v 449.45n 0.0v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 0.0v 529.45n 0.0v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 0.0v 649.45n 0.0v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 0.0v 949.45n 0.0v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 0.0v 989.45n 0.0v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 3.3 9.95n 0.1n 0.1n 4.9n 10n)

 * Generation of dout measurements
* CHECK dout0_0 vdout0_0ck4 = 0 time = 50
* CHECK dout0_1 vdout0_1ck4 = 3.3 time = 50
* CHECK dout0_2 vdout0_2ck4 = 3.3 time = 50
* CHECK dout0_3 vdout0_3ck4 = 0 time = 50
* CHECK dout0_4 vdout0_4ck4 = 3.3 time = 50
* CHECK dout0_5 vdout0_5ck4 = 0 time = 50
* CHECK dout0_6 vdout0_6ck4 = 3.3 time = 50
* CHECK dout0_7 vdout0_7ck4 = 0 time = 50
* CHECK dout0_0 vdout0_0ck5 = 0 time = 60
* CHECK dout0_1 vdout0_1ck5 = 3.3 time = 60
* CHECK dout0_2 vdout0_2ck5 = 3.3 time = 60
* CHECK dout0_3 vdout0_3ck5 = 0 time = 60
* CHECK dout0_4 vdout0_4ck5 = 3.3 time = 60
* CHECK dout0_5 vdout0_5ck5 = 0 time = 60
* CHECK dout0_6 vdout0_6ck5 = 3.3 time = 60
* CHECK dout0_7 vdout0_7ck5 = 0 time = 60
* CHECK dout0_0 vdout0_0ck6 = 0 time = 70
* CHECK dout0_1 vdout0_1ck6 = 3.3 time = 70
* CHECK dout0_2 vdout0_2ck6 = 3.3 time = 70
* CHECK dout0_3 vdout0_3ck6 = 0 time = 70
* CHECK dout0_4 vdout0_4ck6 = 3.3 time = 70
* CHECK dout0_5 vdout0_5ck6 = 0 time = 70
* CHECK dout0_6 vdout0_6ck6 = 3.3 time = 70
* CHECK dout0_7 vdout0_7ck6 = 0 time = 70
* CHECK dout0_0 vdout0_0ck9 = 0 time = 100
* CHECK dout0_1 vdout0_1ck9 = 3.3 time = 100
* CHECK dout0_2 vdout0_2ck9 = 0 time = 100
* CHECK dout0_3 vdout0_3ck9 = 0 time = 100
* CHECK dout0_4 vdout0_4ck9 = 0 time = 100
* CHECK dout0_5 vdout0_5ck9 = 0 time = 100
* CHECK dout0_6 vdout0_6ck9 = 3.3 time = 100
* CHECK dout0_7 vdout0_7ck9 = 3.3 time = 100
* CHECK dout0_0 vdout0_0ck12 = 0 time = 130
* CHECK dout0_1 vdout0_1ck12 = 3.3 time = 130
* CHECK dout0_2 vdout0_2ck12 = 0 time = 130
* CHECK dout0_3 vdout0_3ck12 = 3.3 time = 130
* CHECK dout0_4 vdout0_4ck12 = 3.3 time = 130
* CHECK dout0_5 vdout0_5ck12 = 0 time = 130
* CHECK dout0_6 vdout0_6ck12 = 3.3 time = 130
* CHECK dout0_7 vdout0_7ck12 = 3.3 time = 130
* CHECK dout0_0 vdout0_0ck14 = 0 time = 150
* CHECK dout0_1 vdout0_1ck14 = 3.3 time = 150
* CHECK dout0_2 vdout0_2ck14 = 3.3 time = 150
* CHECK dout0_3 vdout0_3ck14 = 3.3 time = 150
* CHECK dout0_4 vdout0_4ck14 = 3.3 time = 150
* CHECK dout0_5 vdout0_5ck14 = 0 time = 150
* CHECK dout0_6 vdout0_6ck14 = 3.3 time = 150
* CHECK dout0_7 vdout0_7ck14 = 3.3 time = 150
* CHECK dout0_0 vdout0_0ck17 = 0 time = 180
* CHECK dout0_1 vdout0_1ck17 = 3.3 time = 180
* CHECK dout0_2 vdout0_2ck17 = 3.3 time = 180
* CHECK dout0_3 vdout0_3ck17 = 3.3 time = 180
* CHECK dout0_4 vdout0_4ck17 = 3.3 time = 180
* CHECK dout0_5 vdout0_5ck17 = 0 time = 180
* CHECK dout0_6 vdout0_6ck17 = 3.3 time = 180
* CHECK dout0_7 vdout0_7ck17 = 3.3 time = 180
* CHECK dout0_0 vdout0_0ck18 = 0 time = 190
* CHECK dout0_1 vdout0_1ck18 = 3.3 time = 190
* CHECK dout0_2 vdout0_2ck18 = 3.3 time = 190
* CHECK dout0_3 vdout0_3ck18 = 0 time = 190
* CHECK dout0_4 vdout0_4ck18 = 3.3 time = 190
* CHECK dout0_5 vdout0_5ck18 = 0 time = 190
* CHECK dout0_6 vdout0_6ck18 = 0 time = 190
* CHECK dout0_7 vdout0_7ck18 = 0 time = 190
* CHECK dout0_0 vdout0_0ck23 = 3.3 time = 240
* CHECK dout0_1 vdout0_1ck23 = 3.3 time = 240
* CHECK dout0_2 vdout0_2ck23 = 3.3 time = 240
* CHECK dout0_3 vdout0_3ck23 = 3.3 time = 240
* CHECK dout0_4 vdout0_4ck23 = 0 time = 240
* CHECK dout0_5 vdout0_5ck23 = 0 time = 240
* CHECK dout0_6 vdout0_6ck23 = 3.3 time = 240
* CHECK dout0_7 vdout0_7ck23 = 0 time = 240
* CHECK dout0_0 vdout0_0ck25 = 3.3 time = 260
* CHECK dout0_1 vdout0_1ck25 = 0 time = 260
* CHECK dout0_2 vdout0_2ck25 = 3.3 time = 260
* CHECK dout0_3 vdout0_3ck25 = 0 time = 260
* CHECK dout0_4 vdout0_4ck25 = 3.3 time = 260
* CHECK dout0_5 vdout0_5ck25 = 0 time = 260
* CHECK dout0_6 vdout0_6ck25 = 3.3 time = 260
* CHECK dout0_7 vdout0_7ck25 = 3.3 time = 260
* CHECK dout0_0 vdout0_0ck30 = 3.3 time = 310
* CHECK dout0_1 vdout0_1ck30 = 3.3 time = 310
* CHECK dout0_2 vdout0_2ck30 = 3.3 time = 310
* CHECK dout0_3 vdout0_3ck30 = 3.3 time = 310
* CHECK dout0_4 vdout0_4ck30 = 0 time = 310
* CHECK dout0_5 vdout0_5ck30 = 0 time = 310
* CHECK dout0_6 vdout0_6ck30 = 3.3 time = 310
* CHECK dout0_7 vdout0_7ck30 = 0 time = 310
* CHECK dout0_0 vdout0_0ck31 = 3.3 time = 320
* CHECK dout0_1 vdout0_1ck31 = 3.3 time = 320
* CHECK dout0_2 vdout0_2ck31 = 3.3 time = 320
* CHECK dout0_3 vdout0_3ck31 = 0 time = 320
* CHECK dout0_4 vdout0_4ck31 = 3.3 time = 320
* CHECK dout0_5 vdout0_5ck31 = 0 time = 320
* CHECK dout0_6 vdout0_6ck31 = 3.3 time = 320
* CHECK dout0_7 vdout0_7ck31 = 0 time = 320
* CHECK dout0_0 vdout0_0ck32 = 3.3 time = 330
* CHECK dout0_1 vdout0_1ck32 = 3.3 time = 330
* CHECK dout0_2 vdout0_2ck32 = 3.3 time = 330
* CHECK dout0_3 vdout0_3ck32 = 3.3 time = 330
* CHECK dout0_4 vdout0_4ck32 = 0 time = 330
* CHECK dout0_5 vdout0_5ck32 = 0 time = 330
* CHECK dout0_6 vdout0_6ck32 = 3.3 time = 330
* CHECK dout0_7 vdout0_7ck32 = 0 time = 330
* CHECK dout0_0 vdout0_0ck35 = 0 time = 360
* CHECK dout0_1 vdout0_1ck35 = 0 time = 360
* CHECK dout0_2 vdout0_2ck35 = 0 time = 360
* CHECK dout0_3 vdout0_3ck35 = 3.3 time = 360
* CHECK dout0_4 vdout0_4ck35 = 3.3 time = 360
* CHECK dout0_5 vdout0_5ck35 = 0 time = 360
* CHECK dout0_6 vdout0_6ck35 = 0 time = 360
* CHECK dout0_7 vdout0_7ck35 = 3.3 time = 360
* CHECK dout0_0 vdout0_0ck36 = 0 time = 370
* CHECK dout0_1 vdout0_1ck36 = 0 time = 370
* CHECK dout0_2 vdout0_2ck36 = 0 time = 370
* CHECK dout0_3 vdout0_3ck36 = 3.3 time = 370
* CHECK dout0_4 vdout0_4ck36 = 3.3 time = 370
* CHECK dout0_5 vdout0_5ck36 = 0 time = 370
* CHECK dout0_6 vdout0_6ck36 = 0 time = 370
* CHECK dout0_7 vdout0_7ck36 = 3.3 time = 370
* CHECK dout0_0 vdout0_0ck37 = 3.3 time = 380
* CHECK dout0_1 vdout0_1ck37 = 3.3 time = 380
* CHECK dout0_2 vdout0_2ck37 = 3.3 time = 380
* CHECK dout0_3 vdout0_3ck37 = 0 time = 380
* CHECK dout0_4 vdout0_4ck37 = 3.3 time = 380
* CHECK dout0_5 vdout0_5ck37 = 0 time = 380
* CHECK dout0_6 vdout0_6ck37 = 3.3 time = 380
* CHECK dout0_7 vdout0_7ck37 = 0 time = 380
* CHECK dout0_0 vdout0_0ck39 = 3.3 time = 400
* CHECK dout0_1 vdout0_1ck39 = 3.3 time = 400
* CHECK dout0_2 vdout0_2ck39 = 3.3 time = 400
* CHECK dout0_3 vdout0_3ck39 = 0 time = 400
* CHECK dout0_4 vdout0_4ck39 = 0 time = 400
* CHECK dout0_5 vdout0_5ck39 = 0 time = 400
* CHECK dout0_6 vdout0_6ck39 = 0 time = 400
* CHECK dout0_7 vdout0_7ck39 = 0 time = 400
* CHECK dout0_0 vdout0_0ck40 = 3.3 time = 410
* CHECK dout0_1 vdout0_1ck40 = 3.3 time = 410
* CHECK dout0_2 vdout0_2ck40 = 3.3 time = 410
* CHECK dout0_3 vdout0_3ck40 = 0 time = 410
* CHECK dout0_4 vdout0_4ck40 = 0 time = 410
* CHECK dout0_5 vdout0_5ck40 = 0 time = 410
* CHECK dout0_6 vdout0_6ck40 = 0 time = 410
* CHECK dout0_7 vdout0_7ck40 = 0 time = 410
* CHECK dout0_0 vdout0_0ck41 = 3.3 time = 420
* CHECK dout0_1 vdout0_1ck41 = 3.3 time = 420
* CHECK dout0_2 vdout0_2ck41 = 3.3 time = 420
* CHECK dout0_3 vdout0_3ck41 = 0 time = 420
* CHECK dout0_4 vdout0_4ck41 = 0 time = 420
* CHECK dout0_5 vdout0_5ck41 = 0 time = 420
* CHECK dout0_6 vdout0_6ck41 = 0 time = 420
* CHECK dout0_7 vdout0_7ck41 = 0 time = 420
* CHECK dout0_0 vdout0_0ck42 = 3.3 time = 430
* CHECK dout0_1 vdout0_1ck42 = 3.3 time = 430
* CHECK dout0_2 vdout0_2ck42 = 3.3 time = 430
* CHECK dout0_3 vdout0_3ck42 = 0 time = 430
* CHECK dout0_4 vdout0_4ck42 = 0 time = 430
* CHECK dout0_5 vdout0_5ck42 = 0 time = 430
* CHECK dout0_6 vdout0_6ck42 = 0 time = 430
* CHECK dout0_7 vdout0_7ck42 = 0 time = 430
* CHECK dout0_0 vdout0_0ck43 = 3.3 time = 440
* CHECK dout0_1 vdout0_1ck43 = 3.3 time = 440
* CHECK dout0_2 vdout0_2ck43 = 3.3 time = 440
* CHECK dout0_3 vdout0_3ck43 = 0 time = 440
* CHECK dout0_4 vdout0_4ck43 = 0 time = 440
* CHECK dout0_5 vdout0_5ck43 = 0 time = 440
* CHECK dout0_6 vdout0_6ck43 = 0 time = 440
* CHECK dout0_7 vdout0_7ck43 = 0 time = 440
* CHECK dout0_0 vdout0_0ck45 = 3.3 time = 460
* CHECK dout0_1 vdout0_1ck45 = 3.3 time = 460
* CHECK dout0_2 vdout0_2ck45 = 3.3 time = 460
* CHECK dout0_3 vdout0_3ck45 = 0 time = 460
* CHECK dout0_4 vdout0_4ck45 = 0 time = 460
* CHECK dout0_5 vdout0_5ck45 = 0 time = 460
* CHECK dout0_6 vdout0_6ck45 = 0 time = 460
* CHECK dout0_7 vdout0_7ck45 = 0 time = 460
* CHECK dout0_0 vdout0_0ck50 = 3.3 time = 510
* CHECK dout0_1 vdout0_1ck50 = 3.3 time = 510
* CHECK dout0_2 vdout0_2ck50 = 3.3 time = 510
* CHECK dout0_3 vdout0_3ck50 = 0 time = 510
* CHECK dout0_4 vdout0_4ck50 = 0 time = 510
* CHECK dout0_5 vdout0_5ck50 = 0 time = 510
* CHECK dout0_6 vdout0_6ck50 = 0 time = 510
* CHECK dout0_7 vdout0_7ck50 = 0 time = 510
* CHECK dout0_0 vdout0_0ck51 = 3.3 time = 520
* CHECK dout0_1 vdout0_1ck51 = 3.3 time = 520
* CHECK dout0_2 vdout0_2ck51 = 3.3 time = 520
* CHECK dout0_3 vdout0_3ck51 = 0 time = 520
* CHECK dout0_4 vdout0_4ck51 = 3.3 time = 520
* CHECK dout0_5 vdout0_5ck51 = 0 time = 520
* CHECK dout0_6 vdout0_6ck51 = 3.3 time = 520
* CHECK dout0_7 vdout0_7ck51 = 3.3 time = 520
* CHECK dout0_0 vdout0_0ck53 = 3.3 time = 540
* CHECK dout0_1 vdout0_1ck53 = 3.3 time = 540
* CHECK dout0_2 vdout0_2ck53 = 3.3 time = 540
* CHECK dout0_3 vdout0_3ck53 = 0 time = 540
* CHECK dout0_4 vdout0_4ck53 = 0 time = 540
* CHECK dout0_5 vdout0_5ck53 = 0 time = 540
* CHECK dout0_6 vdout0_6ck53 = 0 time = 540
* CHECK dout0_7 vdout0_7ck53 = 0 time = 540
* CHECK dout0_0 vdout0_0ck54 = 3.3 time = 550
* CHECK dout0_1 vdout0_1ck54 = 3.3 time = 550
* CHECK dout0_2 vdout0_2ck54 = 0 time = 550
* CHECK dout0_3 vdout0_3ck54 = 0 time = 550
* CHECK dout0_4 vdout0_4ck54 = 0 time = 550
* CHECK dout0_5 vdout0_5ck54 = 0 time = 550
* CHECK dout0_6 vdout0_6ck54 = 3.3 time = 550
* CHECK dout0_7 vdout0_7ck54 = 0 time = 550
* CHECK dout0_0 vdout0_0ck55 = 3.3 time = 560
* CHECK dout0_1 vdout0_1ck55 = 3.3 time = 560
* CHECK dout0_2 vdout0_2ck55 = 0 time = 560
* CHECK dout0_3 vdout0_3ck55 = 0 time = 560
* CHECK dout0_4 vdout0_4ck55 = 0 time = 560
* CHECK dout0_5 vdout0_5ck55 = 0 time = 560
* CHECK dout0_6 vdout0_6ck55 = 3.3 time = 560
* CHECK dout0_7 vdout0_7ck55 = 0 time = 560
* CHECK dout0_0 vdout0_0ck56 = 3.3 time = 570
* CHECK dout0_1 vdout0_1ck56 = 3.3 time = 570
* CHECK dout0_2 vdout0_2ck56 = 0 time = 570
* CHECK dout0_3 vdout0_3ck56 = 0 time = 570
* CHECK dout0_4 vdout0_4ck56 = 0 time = 570
* CHECK dout0_5 vdout0_5ck56 = 0 time = 570
* CHECK dout0_6 vdout0_6ck56 = 3.3 time = 570
* CHECK dout0_7 vdout0_7ck56 = 0 time = 570
* CHECK dout0_0 vdout0_0ck57 = 3.3 time = 580
* CHECK dout0_1 vdout0_1ck57 = 3.3 time = 580
* CHECK dout0_2 vdout0_2ck57 = 0 time = 580
* CHECK dout0_3 vdout0_3ck57 = 0 time = 580
* CHECK dout0_4 vdout0_4ck57 = 0 time = 580
* CHECK dout0_5 vdout0_5ck57 = 0 time = 580
* CHECK dout0_6 vdout0_6ck57 = 3.3 time = 580
* CHECK dout0_7 vdout0_7ck57 = 0 time = 580
* CHECK dout0_0 vdout0_0ck62 = 0 time = 630
* CHECK dout0_1 vdout0_1ck62 = 3.3 time = 630
* CHECK dout0_2 vdout0_2ck62 = 3.3 time = 630
* CHECK dout0_3 vdout0_3ck62 = 0 time = 630
* CHECK dout0_4 vdout0_4ck62 = 0 time = 630
* CHECK dout0_5 vdout0_5ck62 = 3.3 time = 630
* CHECK dout0_6 vdout0_6ck62 = 0 time = 630
* CHECK dout0_7 vdout0_7ck62 = 3.3 time = 630
* CHECK dout0_0 vdout0_0ck63 = 3.3 time = 640
* CHECK dout0_1 vdout0_1ck63 = 0 time = 640
* CHECK dout0_2 vdout0_2ck63 = 3.3 time = 640
* CHECK dout0_3 vdout0_3ck63 = 3.3 time = 640
* CHECK dout0_4 vdout0_4ck63 = 3.3 time = 640
* CHECK dout0_5 vdout0_5ck63 = 0 time = 640
* CHECK dout0_6 vdout0_6ck63 = 3.3 time = 640
* CHECK dout0_7 vdout0_7ck63 = 0 time = 640
* CHECK dout0_0 vdout0_0ck65 = 0 time = 660
* CHECK dout0_1 vdout0_1ck65 = 3.3 time = 660
* CHECK dout0_2 vdout0_2ck65 = 3.3 time = 660
* CHECK dout0_3 vdout0_3ck65 = 0 time = 660
* CHECK dout0_4 vdout0_4ck65 = 0 time = 660
* CHECK dout0_5 vdout0_5ck65 = 3.3 time = 660
* CHECK dout0_6 vdout0_6ck65 = 0 time = 660
* CHECK dout0_7 vdout0_7ck65 = 3.3 time = 660
* CHECK dout0_0 vdout0_0ck68 = 0 time = 690
* CHECK dout0_1 vdout0_1ck68 = 3.3 time = 690
* CHECK dout0_2 vdout0_2ck68 = 0 time = 690
* CHECK dout0_3 vdout0_3ck68 = 3.3 time = 690
* CHECK dout0_4 vdout0_4ck68 = 3.3 time = 690
* CHECK dout0_5 vdout0_5ck68 = 0 time = 690
* CHECK dout0_6 vdout0_6ck68 = 0 time = 690
* CHECK dout0_7 vdout0_7ck68 = 0 time = 690
* CHECK dout0_0 vdout0_0ck70 = 0 time = 710
* CHECK dout0_1 vdout0_1ck70 = 3.3 time = 710
* CHECK dout0_2 vdout0_2ck70 = 0 time = 710
* CHECK dout0_3 vdout0_3ck70 = 3.3 time = 710
* CHECK dout0_4 vdout0_4ck70 = 3.3 time = 710
* CHECK dout0_5 vdout0_5ck70 = 0 time = 710
* CHECK dout0_6 vdout0_6ck70 = 0 time = 710
* CHECK dout0_7 vdout0_7ck70 = 0 time = 710
* CHECK dout0_0 vdout0_0ck71 = 0 time = 720
* CHECK dout0_1 vdout0_1ck71 = 3.3 time = 720
* CHECK dout0_2 vdout0_2ck71 = 0 time = 720
* CHECK dout0_3 vdout0_3ck71 = 3.3 time = 720
* CHECK dout0_4 vdout0_4ck71 = 3.3 time = 720
* CHECK dout0_5 vdout0_5ck71 = 0 time = 720
* CHECK dout0_6 vdout0_6ck71 = 0 time = 720
* CHECK dout0_7 vdout0_7ck71 = 0 time = 720
* CHECK dout0_0 vdout0_0ck78 = 0 time = 790
* CHECK dout0_1 vdout0_1ck78 = 3.3 time = 790
* CHECK dout0_2 vdout0_2ck78 = 0 time = 790
* CHECK dout0_3 vdout0_3ck78 = 3.3 time = 790
* CHECK dout0_4 vdout0_4ck78 = 3.3 time = 790
* CHECK dout0_5 vdout0_5ck78 = 0 time = 790
* CHECK dout0_6 vdout0_6ck78 = 0 time = 790
* CHECK dout0_7 vdout0_7ck78 = 0 time = 790
* CHECK dout0_0 vdout0_0ck79 = 0 time = 800
* CHECK dout0_1 vdout0_1ck79 = 0 time = 800
* CHECK dout0_2 vdout0_2ck79 = 3.3 time = 800
* CHECK dout0_3 vdout0_3ck79 = 3.3 time = 800
* CHECK dout0_4 vdout0_4ck79 = 0 time = 800
* CHECK dout0_5 vdout0_5ck79 = 0 time = 800
* CHECK dout0_6 vdout0_6ck79 = 3.3 time = 800
* CHECK dout0_7 vdout0_7ck79 = 3.3 time = 800
* CHECK dout0_0 vdout0_0ck80 = 0 time = 810
* CHECK dout0_1 vdout0_1ck80 = 0 time = 810
* CHECK dout0_2 vdout0_2ck80 = 3.3 time = 810
* CHECK dout0_3 vdout0_3ck80 = 3.3 time = 810
* CHECK dout0_4 vdout0_4ck80 = 0 time = 810
* CHECK dout0_5 vdout0_5ck80 = 0 time = 810
* CHECK dout0_6 vdout0_6ck80 = 3.3 time = 810
* CHECK dout0_7 vdout0_7ck80 = 3.3 time = 810
* CHECK dout0_0 vdout0_0ck82 = 0 time = 830
* CHECK dout0_1 vdout0_1ck82 = 0 time = 830
* CHECK dout0_2 vdout0_2ck82 = 3.3 time = 830
* CHECK dout0_3 vdout0_3ck82 = 3.3 time = 830
* CHECK dout0_4 vdout0_4ck82 = 0 time = 830
* CHECK dout0_5 vdout0_5ck82 = 0 time = 830
* CHECK dout0_6 vdout0_6ck82 = 3.3 time = 830
* CHECK dout0_7 vdout0_7ck82 = 3.3 time = 830
* CHECK dout0_0 vdout0_0ck86 = 0 time = 870
* CHECK dout0_1 vdout0_1ck86 = 3.3 time = 870
* CHECK dout0_2 vdout0_2ck86 = 0 time = 870
* CHECK dout0_3 vdout0_3ck86 = 3.3 time = 870
* CHECK dout0_4 vdout0_4ck86 = 3.3 time = 870
* CHECK dout0_5 vdout0_5ck86 = 0 time = 870
* CHECK dout0_6 vdout0_6ck86 = 0 time = 870
* CHECK dout0_7 vdout0_7ck86 = 0 time = 870
* CHECK dout0_0 vdout0_0ck89 = 0 time = 900
* CHECK dout0_1 vdout0_1ck89 = 3.3 time = 900
* CHECK dout0_2 vdout0_2ck89 = 0 time = 900
* CHECK dout0_3 vdout0_3ck89 = 3.3 time = 900
* CHECK dout0_4 vdout0_4ck89 = 3.3 time = 900
* CHECK dout0_5 vdout0_5ck89 = 0 time = 900
* CHECK dout0_6 vdout0_6ck89 = 0 time = 900
* CHECK dout0_7 vdout0_7ck89 = 3.3 time = 900
* CHECK dout0_0 vdout0_0ck90 = 0 time = 910
* CHECK dout0_1 vdout0_1ck90 = 3.3 time = 910
* CHECK dout0_2 vdout0_2ck90 = 0 time = 910
* CHECK dout0_3 vdout0_3ck90 = 3.3 time = 910
* CHECK dout0_4 vdout0_4ck90 = 3.3 time = 910
* CHECK dout0_5 vdout0_5ck90 = 0 time = 910
* CHECK dout0_6 vdout0_6ck90 = 0 time = 910
* CHECK dout0_7 vdout0_7ck90 = 3.3 time = 910
* CHECK dout0_0 vdout0_0ck91 = 0 time = 920
* CHECK dout0_1 vdout0_1ck91 = 3.3 time = 920
* CHECK dout0_2 vdout0_2ck91 = 0 time = 920
* CHECK dout0_3 vdout0_3ck91 = 3.3 time = 920
* CHECK dout0_4 vdout0_4ck91 = 3.3 time = 920
* CHECK dout0_5 vdout0_5ck91 = 0 time = 920
* CHECK dout0_6 vdout0_6ck91 = 0 time = 920
* CHECK dout0_7 vdout0_7ck91 = 0 time = 920
* CHECK dout0_0 vdout0_0ck92 = 0 time = 930
* CHECK dout0_1 vdout0_1ck92 = 3.3 time = 930
* CHECK dout0_2 vdout0_2ck92 = 0 time = 930
* CHECK dout0_3 vdout0_3ck92 = 3.3 time = 930
* CHECK dout0_4 vdout0_4ck92 = 3.3 time = 930
* CHECK dout0_5 vdout0_5ck92 = 0 time = 930
* CHECK dout0_6 vdout0_6ck92 = 0 time = 930
* CHECK dout0_7 vdout0_7ck92 = 3.3 time = 930
* CHECK dout0_0 vdout0_0ck93 = 0 time = 940
* CHECK dout0_1 vdout0_1ck93 = 3.3 time = 940
* CHECK dout0_2 vdout0_2ck93 = 0 time = 940
* CHECK dout0_3 vdout0_3ck93 = 3.3 time = 940
* CHECK dout0_4 vdout0_4ck93 = 3.3 time = 940
* CHECK dout0_5 vdout0_5ck93 = 0 time = 940
* CHECK dout0_6 vdout0_6ck93 = 0 time = 940
* CHECK dout0_7 vdout0_7ck93 = 0 time = 940
* CHECK dout0_0 vdout0_0ck96 = 0 time = 970
* CHECK dout0_1 vdout0_1ck96 = 0 time = 970
* CHECK dout0_2 vdout0_2ck96 = 3.3 time = 970
* CHECK dout0_3 vdout0_3ck96 = 0 time = 970
* CHECK dout0_4 vdout0_4ck96 = 0 time = 970
* CHECK dout0_5 vdout0_5ck96 = 0 time = 970
* CHECK dout0_6 vdout0_6ck96 = 3.3 time = 970
* CHECK dout0_7 vdout0_7ck96 = 3.3 time = 970
* CHECK dout0_0 vdout0_0ck97 = 0 time = 980
* CHECK dout0_1 vdout0_1ck97 = 0 time = 980
* CHECK dout0_2 vdout0_2ck97 = 3.3 time = 980
* CHECK dout0_3 vdout0_3ck97 = 0 time = 980
* CHECK dout0_4 vdout0_4ck97 = 0 time = 980
* CHECK dout0_5 vdout0_5ck97 = 0 time = 980
* CHECK dout0_6 vdout0_6ck97 = 3.3 time = 980
* CHECK dout0_7 vdout0_7ck97 = 3.3 time = 980
* CHECK dout0_0 vdout0_0ck99 = 3.3 time = 1000
* CHECK dout0_1 vdout0_1ck99 = 0 time = 1000
* CHECK dout0_2 vdout0_2ck99 = 0 time = 1000
* CHECK dout0_3 vdout0_3ck99 = 3.3 time = 1000
* CHECK dout0_4 vdout0_4ck99 = 0 time = 1000
* CHECK dout0_5 vdout0_5ck99 = 0 time = 1000
* CHECK dout0_6 vdout0_6ck99 = 0 time = 1000
* CHECK dout0_7 vdout0_7ck99 = 0 time = 1000
* CHECK dout0_0 vdout0_0ck100 = 3.3 time = 1010
* CHECK dout0_1 vdout0_1ck100 = 0 time = 1010
* CHECK dout0_2 vdout0_2ck100 = 0 time = 1010
* CHECK dout0_3 vdout0_3ck100 = 3.3 time = 1010
* CHECK dout0_4 vdout0_4ck100 = 0 time = 1010
* CHECK dout0_5 vdout0_5ck100 = 0 time = 1010
* CHECK dout0_6 vdout0_6ck100 = 0 time = 1010
* CHECK dout0_7 vdout0_7ck100 = 0 time = 1010
* CHECK dout0_0 vdout0_0ck106 = 3.3 time = 1070
* CHECK dout0_1 vdout0_1ck106 = 3.3 time = 1070
* CHECK dout0_2 vdout0_2ck106 = 3.3 time = 1070
* CHECK dout0_3 vdout0_3ck106 = 0 time = 1070
* CHECK dout0_4 vdout0_4ck106 = 0 time = 1070
* CHECK dout0_5 vdout0_5ck106 = 0 time = 1070
* CHECK dout0_6 vdout0_6ck106 = 3.3 time = 1070
* CHECK dout0_7 vdout0_7ck106 = 0 time = 1070
* CHECK dout0_0 vdout0_0ck107 = 3.3 time = 1080
* CHECK dout0_1 vdout0_1ck107 = 3.3 time = 1080
* CHECK dout0_2 vdout0_2ck107 = 3.3 time = 1080
* CHECK dout0_3 vdout0_3ck107 = 0 time = 1080
* CHECK dout0_4 vdout0_4ck107 = 0 time = 1080
* CHECK dout0_5 vdout0_5ck107 = 0 time = 1080
* CHECK dout0_6 vdout0_6ck107 = 3.3 time = 1080
* CHECK dout0_7 vdout0_7ck107 = 0 time = 1080
* CHECK dout0_0 vdout0_0ck108 = 3.3 time = 1090
* CHECK dout0_1 vdout0_1ck108 = 3.3 time = 1090
* CHECK dout0_2 vdout0_2ck108 = 3.3 time = 1090
* CHECK dout0_3 vdout0_3ck108 = 0 time = 1090
* CHECK dout0_4 vdout0_4ck108 = 0 time = 1090
* CHECK dout0_5 vdout0_5ck108 = 0 time = 1090
* CHECK dout0_6 vdout0_6ck108 = 3.3 time = 1090
* CHECK dout0_7 vdout0_7ck108 = 0 time = 1090
* CHECK dout0_0 vdout0_0ck110 = 0 time = 1110
* CHECK dout0_1 vdout0_1ck110 = 0 time = 1110
* CHECK dout0_2 vdout0_2ck110 = 3.3 time = 1110
* CHECK dout0_3 vdout0_3ck110 = 0 time = 1110
* CHECK dout0_4 vdout0_4ck110 = 0 time = 1110
* CHECK dout0_5 vdout0_5ck110 = 0 time = 1110
* CHECK dout0_6 vdout0_6ck110 = 3.3 time = 1110
* CHECK dout0_7 vdout0_7ck110 = 3.3 time = 1110
* CHECK dout0_0 vdout0_0ck112 = 0 time = 1130
* CHECK dout0_1 vdout0_1ck112 = 0 time = 1130
* CHECK dout0_2 vdout0_2ck112 = 3.3 time = 1130
* CHECK dout0_3 vdout0_3ck112 = 0 time = 1130
* CHECK dout0_4 vdout0_4ck112 = 0 time = 1130
* CHECK dout0_5 vdout0_5ck112 = 0 time = 1130
* CHECK dout0_6 vdout0_6ck112 = 3.3 time = 1130
* CHECK dout0_7 vdout0_7ck112 = 3.3 time = 1130
* CHECK dout0_0 vdout0_0ck113 = 3.3 time = 1140
* CHECK dout0_1 vdout0_1ck113 = 3.3 time = 1140
* CHECK dout0_2 vdout0_2ck113 = 0 time = 1140
* CHECK dout0_3 vdout0_3ck113 = 3.3 time = 1140
* CHECK dout0_4 vdout0_4ck113 = 3.3 time = 1140
* CHECK dout0_5 vdout0_5ck113 = 3.3 time = 1140
* CHECK dout0_6 vdout0_6ck113 = 0 time = 1140
* CHECK dout0_7 vdout0_7ck113 = 0 time = 1140
* CHECK dout0_0 vdout0_0ck114 = 0 time = 1150
* CHECK dout0_1 vdout0_1ck114 = 0 time = 1150
* CHECK dout0_2 vdout0_2ck114 = 3.3 time = 1150
* CHECK dout0_3 vdout0_3ck114 = 0 time = 1150
* CHECK dout0_4 vdout0_4ck114 = 0 time = 1150
* CHECK dout0_5 vdout0_5ck114 = 0 time = 1150
* CHECK dout0_6 vdout0_6ck114 = 3.3 time = 1150
* CHECK dout0_7 vdout0_7ck114 = 3.3 time = 1150
* CHECK dout0_0 vdout0_0ck115 = 3.3 time = 1160
* CHECK dout0_1 vdout0_1ck115 = 3.3 time = 1160
* CHECK dout0_2 vdout0_2ck115 = 0 time = 1160
* CHECK dout0_3 vdout0_3ck115 = 3.3 time = 1160
* CHECK dout0_4 vdout0_4ck115 = 3.3 time = 1160
* CHECK dout0_5 vdout0_5ck115 = 3.3 time = 1160
* CHECK dout0_6 vdout0_6ck115 = 0 time = 1160
* CHECK dout0_7 vdout0_7ck115 = 0 time = 1160
* CHECK dout0_0 vdout0_0ck119 = 0 time = 1200
* CHECK dout0_1 vdout0_1ck119 = 0 time = 1200
* CHECK dout0_2 vdout0_2ck119 = 3.3 time = 1200
* CHECK dout0_3 vdout0_3ck119 = 0 time = 1200
* CHECK dout0_4 vdout0_4ck119 = 0 time = 1200
* CHECK dout0_5 vdout0_5ck119 = 0 time = 1200
* CHECK dout0_6 vdout0_6ck119 = 3.3 time = 1200
* CHECK dout0_7 vdout0_7ck119 = 3.3 time = 1200
* CHECK dout0_0 vdout0_0ck121 = 0 time = 1220
* CHECK dout0_1 vdout0_1ck121 = 0 time = 1220
* CHECK dout0_2 vdout0_2ck121 = 3.3 time = 1220
* CHECK dout0_3 vdout0_3ck121 = 0 time = 1220
* CHECK dout0_4 vdout0_4ck121 = 0 time = 1220
* CHECK dout0_5 vdout0_5ck121 = 0 time = 1220
* CHECK dout0_6 vdout0_6ck121 = 3.3 time = 1220
* CHECK dout0_7 vdout0_7ck121 = 3.3 time = 1220
* CHECK dout0_0 vdout0_0ck122 = 0 time = 1230
* CHECK dout0_1 vdout0_1ck122 = 0 time = 1230
* CHECK dout0_2 vdout0_2ck122 = 3.3 time = 1230
* CHECK dout0_3 vdout0_3ck122 = 0 time = 1230
* CHECK dout0_4 vdout0_4ck122 = 0 time = 1230
* CHECK dout0_5 vdout0_5ck122 = 0 time = 1230
* CHECK dout0_6 vdout0_6ck122 = 3.3 time = 1230
* CHECK dout0_7 vdout0_7ck122 = 3.3 time = 1230
* CHECK dout0_0 vdout0_0ck123 = 0 time = 1240
* CHECK dout0_1 vdout0_1ck123 = 0 time = 1240
* CHECK dout0_2 vdout0_2ck123 = 3.3 time = 1240
* CHECK dout0_3 vdout0_3ck123 = 0 time = 1240
* CHECK dout0_4 vdout0_4ck123 = 0 time = 1240
* CHECK dout0_5 vdout0_5ck123 = 0 time = 1240
* CHECK dout0_6 vdout0_6ck123 = 3.3 time = 1240
* CHECK dout0_7 vdout0_7ck123 = 3.3 time = 1240
* CHECK dout0_0 vdout0_0ck125 = 0 time = 1260
* CHECK dout0_1 vdout0_1ck125 = 0 time = 1260
* CHECK dout0_2 vdout0_2ck125 = 3.3 time = 1260
* CHECK dout0_3 vdout0_3ck125 = 0 time = 1260
* CHECK dout0_4 vdout0_4ck125 = 0 time = 1260
* CHECK dout0_5 vdout0_5ck125 = 0 time = 1260
* CHECK dout0_6 vdout0_6ck125 = 3.3 time = 1260
* CHECK dout0_7 vdout0_7ck125 = 3.3 time = 1260
* CHECK dout0_0 vdout0_0ck126 = 0 time = 1270
* CHECK dout0_1 vdout0_1ck126 = 0 time = 1270
* CHECK dout0_2 vdout0_2ck126 = 3.3 time = 1270
* CHECK dout0_3 vdout0_3ck126 = 0 time = 1270
* CHECK dout0_4 vdout0_4ck126 = 0 time = 1270
* CHECK dout0_5 vdout0_5ck126 = 0 time = 1270
* CHECK dout0_6 vdout0_6ck126 = 3.3 time = 1270
* CHECK dout0_7 vdout0_7ck126 = 3.3 time = 1270
* CHECK dout0_0 vdout0_0ck127 = 0 time = 1280
* CHECK dout0_1 vdout0_1ck127 = 0 time = 1280
* CHECK dout0_2 vdout0_2ck127 = 3.3 time = 1280
* CHECK dout0_3 vdout0_3ck127 = 0 time = 1280
* CHECK dout0_4 vdout0_4ck127 = 0 time = 1280
* CHECK dout0_5 vdout0_5ck127 = 0 time = 1280
* CHECK dout0_6 vdout0_6ck127 = 3.3 time = 1280
* CHECK dout0_7 vdout0_7ck127 = 3.3 time = 1280
* CHECK dout0_0 vdout0_0ck129 = 0 time = 1300
* CHECK dout0_1 vdout0_1ck129 = 0 time = 1300
* CHECK dout0_2 vdout0_2ck129 = 3.3 time = 1300
* CHECK dout0_3 vdout0_3ck129 = 0 time = 1300
* CHECK dout0_4 vdout0_4ck129 = 0 time = 1300
* CHECK dout0_5 vdout0_5ck129 = 0 time = 1300
* CHECK dout0_6 vdout0_6ck129 = 3.3 time = 1300
* CHECK dout0_7 vdout0_7ck129 = 3.3 time = 1300
* CHECK dout0_0 vdout0_0ck131 = 3.3 time = 1320
* CHECK dout0_1 vdout0_1ck131 = 3.3 time = 1320
* CHECK dout0_2 vdout0_2ck131 = 0 time = 1320
* CHECK dout0_3 vdout0_3ck131 = 0 time = 1320
* CHECK dout0_4 vdout0_4ck131 = 0 time = 1320
* CHECK dout0_5 vdout0_5ck131 = 0 time = 1320
* CHECK dout0_6 vdout0_6ck131 = 3.3 time = 1320
* CHECK dout0_7 vdout0_7ck131 = 3.3 time = 1320
* CHECK dout0_0 vdout0_0ck134 = 3.3 time = 1350
* CHECK dout0_1 vdout0_1ck134 = 3.3 time = 1350
* CHECK dout0_2 vdout0_2ck134 = 0 time = 1350
* CHECK dout0_3 vdout0_3ck134 = 0 time = 1350
* CHECK dout0_4 vdout0_4ck134 = 0 time = 1350
* CHECK dout0_5 vdout0_5ck134 = 0 time = 1350
* CHECK dout0_6 vdout0_6ck134 = 3.3 time = 1350
* CHECK dout0_7 vdout0_7ck134 = 3.3 time = 1350
* CHECK dout0_0 vdout0_0ck141 = 3.3 time = 1420
* CHECK dout0_1 vdout0_1ck141 = 3.3 time = 1420
* CHECK dout0_2 vdout0_2ck141 = 0 time = 1420
* CHECK dout0_3 vdout0_3ck141 = 0 time = 1420
* CHECK dout0_4 vdout0_4ck141 = 0 time = 1420
* CHECK dout0_5 vdout0_5ck141 = 0 time = 1420
* CHECK dout0_6 vdout0_6ck141 = 3.3 time = 1420
* CHECK dout0_7 vdout0_7ck141 = 3.3 time = 1420
* CHECK dout0_0 vdout0_0ck142 = 0 time = 1430
* CHECK dout0_1 vdout0_1ck142 = 0 time = 1430
* CHECK dout0_2 vdout0_2ck142 = 3.3 time = 1430
* CHECK dout0_3 vdout0_3ck142 = 3.3 time = 1430
* CHECK dout0_4 vdout0_4ck142 = 0 time = 1430
* CHECK dout0_5 vdout0_5ck142 = 3.3 time = 1430
* CHECK dout0_6 vdout0_6ck142 = 0 time = 1430
* CHECK dout0_7 vdout0_7ck142 = 3.3 time = 1430
* CHECK dout0_0 vdout0_0ck143 = 3.3 time = 1440
* CHECK dout0_1 vdout0_1ck143 = 3.3 time = 1440
* CHECK dout0_2 vdout0_2ck143 = 0 time = 1440
* CHECK dout0_3 vdout0_3ck143 = 0 time = 1440
* CHECK dout0_4 vdout0_4ck143 = 0 time = 1440
* CHECK dout0_5 vdout0_5ck143 = 0 time = 1440
* CHECK dout0_6 vdout0_6ck143 = 3.3 time = 1440
* CHECK dout0_7 vdout0_7ck143 = 3.3 time = 1440
* CHECK dout0_0 vdout0_0ck144 = 3.3 time = 1450
* CHECK dout0_1 vdout0_1ck144 = 3.3 time = 1450
* CHECK dout0_2 vdout0_2ck144 = 0 time = 1450
* CHECK dout0_3 vdout0_3ck144 = 0 time = 1450
* CHECK dout0_4 vdout0_4ck144 = 0 time = 1450
* CHECK dout0_5 vdout0_5ck144 = 0 time = 1450
* CHECK dout0_6 vdout0_6ck144 = 3.3 time = 1450
* CHECK dout0_7 vdout0_7ck144 = 3.3 time = 1450
* CHECK dout0_0 vdout0_0ck145 = 3.3 time = 1460
* CHECK dout0_1 vdout0_1ck145 = 3.3 time = 1460
* CHECK dout0_2 vdout0_2ck145 = 0 time = 1460
* CHECK dout0_3 vdout0_3ck145 = 0 time = 1460
* CHECK dout0_4 vdout0_4ck145 = 0 time = 1460
* CHECK dout0_5 vdout0_5ck145 = 0 time = 1460
* CHECK dout0_6 vdout0_6ck145 = 3.3 time = 1460
* CHECK dout0_7 vdout0_7ck145 = 3.3 time = 1460
* CHECK dout0_0 vdout0_0ck146 = 0 time = 1470
* CHECK dout0_1 vdout0_1ck146 = 0 time = 1470
* CHECK dout0_2 vdout0_2ck146 = 3.3 time = 1470
* CHECK dout0_3 vdout0_3ck146 = 3.3 time = 1470
* CHECK dout0_4 vdout0_4ck146 = 0 time = 1470
* CHECK dout0_5 vdout0_5ck146 = 3.3 time = 1470
* CHECK dout0_6 vdout0_6ck146 = 0 time = 1470
* CHECK dout0_7 vdout0_7ck146 = 3.3 time = 1470
* CHECK dout0_0 vdout0_0ck147 = 0 time = 1480
* CHECK dout0_1 vdout0_1ck147 = 0 time = 1480
* CHECK dout0_2 vdout0_2ck147 = 3.3 time = 1480
* CHECK dout0_3 vdout0_3ck147 = 3.3 time = 1480
* CHECK dout0_4 vdout0_4ck147 = 0 time = 1480
* CHECK dout0_5 vdout0_5ck147 = 3.3 time = 1480
* CHECK dout0_6 vdout0_6ck147 = 0 time = 1480
* CHECK dout0_7 vdout0_7ck147 = 3.3 time = 1480
* CHECK dout0_0 vdout0_0ck152 = 3.3 time = 1530
* CHECK dout0_1 vdout0_1ck152 = 3.3 time = 1530
* CHECK dout0_2 vdout0_2ck152 = 0 time = 1530
* CHECK dout0_3 vdout0_3ck152 = 0 time = 1530
* CHECK dout0_4 vdout0_4ck152 = 0 time = 1530
* CHECK dout0_5 vdout0_5ck152 = 3.3 time = 1530
* CHECK dout0_6 vdout0_6ck152 = 0 time = 1530
* CHECK dout0_7 vdout0_7ck152 = 0 time = 1530
* CHECK dout0_0 vdout0_0ck154 = 0 time = 1550
* CHECK dout0_1 vdout0_1ck154 = 0 time = 1550
* CHECK dout0_2 vdout0_2ck154 = 3.3 time = 1550
* CHECK dout0_3 vdout0_3ck154 = 3.3 time = 1550
* CHECK dout0_4 vdout0_4ck154 = 0 time = 1550
* CHECK dout0_5 vdout0_5ck154 = 3.3 time = 1550
* CHECK dout0_6 vdout0_6ck154 = 0 time = 1550
* CHECK dout0_7 vdout0_7ck154 = 3.3 time = 1550
* CHECK dout0_0 vdout0_0ck155 = 0 time = 1560
* CHECK dout0_1 vdout0_1ck155 = 0 time = 1560
* CHECK dout0_2 vdout0_2ck155 = 3.3 time = 1560
* CHECK dout0_3 vdout0_3ck155 = 3.3 time = 1560
* CHECK dout0_4 vdout0_4ck155 = 0 time = 1560
* CHECK dout0_5 vdout0_5ck155 = 3.3 time = 1560
* CHECK dout0_6 vdout0_6ck155 = 0 time = 1560
* CHECK dout0_7 vdout0_7ck155 = 3.3 time = 1560
* CHECK dout0_0 vdout0_0ck156 = 0 time = 1570
* CHECK dout0_1 vdout0_1ck156 = 0 time = 1570
* CHECK dout0_2 vdout0_2ck156 = 3.3 time = 1570
* CHECK dout0_3 vdout0_3ck156 = 3.3 time = 1570
* CHECK dout0_4 vdout0_4ck156 = 0 time = 1570
* CHECK dout0_5 vdout0_5ck156 = 3.3 time = 1570
* CHECK dout0_6 vdout0_6ck156 = 0 time = 1570
* CHECK dout0_7 vdout0_7ck156 = 3.3 time = 1570
* CHECK dout0_0 vdout0_0ck159 = 0 time = 1600
* CHECK dout0_1 vdout0_1ck159 = 0 time = 1600
* CHECK dout0_2 vdout0_2ck159 = 0 time = 1600
* CHECK dout0_3 vdout0_3ck159 = 0 time = 1600
* CHECK dout0_4 vdout0_4ck159 = 0 time = 1600
* CHECK dout0_5 vdout0_5ck159 = 3.3 time = 1600
* CHECK dout0_6 vdout0_6ck159 = 0 time = 1600
* CHECK dout0_7 vdout0_7ck159 = 0 time = 1600
* CHECK dout0_0 vdout0_0ck160 = 3.3 time = 1610
* CHECK dout0_1 vdout0_1ck160 = 3.3 time = 1610
* CHECK dout0_2 vdout0_2ck160 = 0 time = 1610
* CHECK dout0_3 vdout0_3ck160 = 0 time = 1610
* CHECK dout0_4 vdout0_4ck160 = 0 time = 1610
* CHECK dout0_5 vdout0_5ck160 = 3.3 time = 1610
* CHECK dout0_6 vdout0_6ck160 = 0 time = 1610
* CHECK dout0_7 vdout0_7ck160 = 0 time = 1610
* CHECK dout0_0 vdout0_0ck161 = 0 time = 1620
* CHECK dout0_1 vdout0_1ck161 = 0 time = 1620
* CHECK dout0_2 vdout0_2ck161 = 0 time = 1620
* CHECK dout0_3 vdout0_3ck161 = 0 time = 1620
* CHECK dout0_4 vdout0_4ck161 = 0 time = 1620
* CHECK dout0_5 vdout0_5ck161 = 3.3 time = 1620
* CHECK dout0_6 vdout0_6ck161 = 0 time = 1620
* CHECK dout0_7 vdout0_7ck161 = 0 time = 1620
* CHECK dout0_0 vdout0_0ck163 = 0 time = 1640
* CHECK dout0_1 vdout0_1ck163 = 0 time = 1640
* CHECK dout0_2 vdout0_2ck163 = 0 time = 1640
* CHECK dout0_3 vdout0_3ck163 = 0 time = 1640
* CHECK dout0_4 vdout0_4ck163 = 0 time = 1640
* CHECK dout0_5 vdout0_5ck163 = 3.3 time = 1640
* CHECK dout0_6 vdout0_6ck163 = 0 time = 1640
* CHECK dout0_7 vdout0_7ck163 = 0 time = 1640
* CHECK dout0_0 vdout0_0ck164 = 0 time = 1650
* CHECK dout0_1 vdout0_1ck164 = 0 time = 1650
* CHECK dout0_2 vdout0_2ck164 = 0 time = 1650
* CHECK dout0_3 vdout0_3ck164 = 0 time = 1650
* CHECK dout0_4 vdout0_4ck164 = 0 time = 1650
* CHECK dout0_5 vdout0_5ck164 = 3.3 time = 1650
* CHECK dout0_6 vdout0_6ck164 = 0 time = 1650
* CHECK dout0_7 vdout0_7ck164 = 0 time = 1650
* CHECK dout0_0 vdout0_0ck165 = 3.3 time = 1660
* CHECK dout0_1 vdout0_1ck165 = 3.3 time = 1660
* CHECK dout0_2 vdout0_2ck165 = 0 time = 1660
* CHECK dout0_3 vdout0_3ck165 = 0 time = 1660
* CHECK dout0_4 vdout0_4ck165 = 0 time = 1660
* CHECK dout0_5 vdout0_5ck165 = 3.3 time = 1660
* CHECK dout0_6 vdout0_6ck165 = 0 time = 1660
* CHECK dout0_7 vdout0_7ck165 = 0 time = 1660
* CHECK dout0_0 vdout0_0ck166 = 3.3 time = 1670
* CHECK dout0_1 vdout0_1ck166 = 3.3 time = 1670
* CHECK dout0_2 vdout0_2ck166 = 0 time = 1670
* CHECK dout0_3 vdout0_3ck166 = 0 time = 1670
* CHECK dout0_4 vdout0_4ck166 = 0 time = 1670
* CHECK dout0_5 vdout0_5ck166 = 3.3 time = 1670
* CHECK dout0_6 vdout0_6ck166 = 0 time = 1670
* CHECK dout0_7 vdout0_7ck166 = 0 time = 1670
* CHECK dout0_0 vdout0_0ck168 = 3.3 time = 1690
* CHECK dout0_1 vdout0_1ck168 = 3.3 time = 1690
* CHECK dout0_2 vdout0_2ck168 = 0 time = 1690
* CHECK dout0_3 vdout0_3ck168 = 0 time = 1690
* CHECK dout0_4 vdout0_4ck168 = 0 time = 1690
* CHECK dout0_5 vdout0_5ck168 = 3.3 time = 1690
* CHECK dout0_6 vdout0_6ck168 = 0 time = 1690
* CHECK dout0_7 vdout0_7ck168 = 0 time = 1690
* CHECK dout0_0 vdout0_0ck174 = 0 time = 1750
* CHECK dout0_1 vdout0_1ck174 = 3.3 time = 1750
* CHECK dout0_2 vdout0_2ck174 = 3.3 time = 1750
* CHECK dout0_3 vdout0_3ck174 = 0 time = 1750
* CHECK dout0_4 vdout0_4ck174 = 3.3 time = 1750
* CHECK dout0_5 vdout0_5ck174 = 3.3 time = 1750
* CHECK dout0_6 vdout0_6ck174 = 3.3 time = 1750
* CHECK dout0_7 vdout0_7ck174 = 3.3 time = 1750
* CHECK dout0_0 vdout0_0ck176 = 0 time = 1770
* CHECK dout0_1 vdout0_1ck176 = 3.3 time = 1770
* CHECK dout0_2 vdout0_2ck176 = 3.3 time = 1770
* CHECK dout0_3 vdout0_3ck176 = 0 time = 1770
* CHECK dout0_4 vdout0_4ck176 = 3.3 time = 1770
* CHECK dout0_5 vdout0_5ck176 = 3.3 time = 1770
* CHECK dout0_6 vdout0_6ck176 = 3.3 time = 1770
* CHECK dout0_7 vdout0_7ck176 = 3.3 time = 1770
* CHECK dout0_0 vdout0_0ck178 = 0 time = 1790
* CHECK dout0_1 vdout0_1ck178 = 3.3 time = 1790
* CHECK dout0_2 vdout0_2ck178 = 3.3 time = 1790
* CHECK dout0_3 vdout0_3ck178 = 0 time = 1790
* CHECK dout0_4 vdout0_4ck178 = 3.3 time = 1790
* CHECK dout0_5 vdout0_5ck178 = 3.3 time = 1790
* CHECK dout0_6 vdout0_6ck178 = 3.3 time = 1790
* CHECK dout0_7 vdout0_7ck178 = 3.3 time = 1790
* CHECK dout0_0 vdout0_0ck182 = 0 time = 1830
* CHECK dout0_1 vdout0_1ck182 = 3.3 time = 1830
* CHECK dout0_2 vdout0_2ck182 = 0 time = 1830
* CHECK dout0_3 vdout0_3ck182 = 0 time = 1830
* CHECK dout0_4 vdout0_4ck182 = 0 time = 1830
* CHECK dout0_5 vdout0_5ck182 = 0 time = 1830
* CHECK dout0_6 vdout0_6ck182 = 0 time = 1830
* CHECK dout0_7 vdout0_7ck182 = 3.3 time = 1830
* CHECK dout0_0 vdout0_0ck183 = 3.3 time = 1840
* CHECK dout0_1 vdout0_1ck183 = 3.3 time = 1840
* CHECK dout0_2 vdout0_2ck183 = 3.3 time = 1840
* CHECK dout0_3 vdout0_3ck183 = 3.3 time = 1840
* CHECK dout0_4 vdout0_4ck183 = 3.3 time = 1840
* CHECK dout0_5 vdout0_5ck183 = 0 time = 1840
* CHECK dout0_6 vdout0_6ck183 = 3.3 time = 1840
* CHECK dout0_7 vdout0_7ck183 = 0 time = 1840
* CHECK dout0_0 vdout0_0ck186 = 0 time = 1870
* CHECK dout0_1 vdout0_1ck186 = 3.3 time = 1870
* CHECK dout0_2 vdout0_2ck186 = 0 time = 1870
* CHECK dout0_3 vdout0_3ck186 = 0 time = 1870
* CHECK dout0_4 vdout0_4ck186 = 0 time = 1870
* CHECK dout0_5 vdout0_5ck186 = 0 time = 1870
* CHECK dout0_6 vdout0_6ck186 = 0 time = 1870
* CHECK dout0_7 vdout0_7ck186 = 3.3 time = 1870
* CHECK dout0_0 vdout0_0ck188 = 0 time = 1890
* CHECK dout0_1 vdout0_1ck188 = 3.3 time = 1890
* CHECK dout0_2 vdout0_2ck188 = 0 time = 1890
* CHECK dout0_3 vdout0_3ck188 = 0 time = 1890
* CHECK dout0_4 vdout0_4ck188 = 0 time = 1890
* CHECK dout0_5 vdout0_5ck188 = 0 time = 1890
* CHECK dout0_6 vdout0_6ck188 = 0 time = 1890
* CHECK dout0_7 vdout0_7ck188 = 3.3 time = 1890
* CHECK dout0_0 vdout0_0ck191 = 0 time = 1920
* CHECK dout0_1 vdout0_1ck191 = 3.3 time = 1920
* CHECK dout0_2 vdout0_2ck191 = 3.3 time = 1920
* CHECK dout0_3 vdout0_3ck191 = 0 time = 1920
* CHECK dout0_4 vdout0_4ck191 = 0 time = 1920
* CHECK dout0_5 vdout0_5ck191 = 0 time = 1920
* CHECK dout0_6 vdout0_6ck191 = 0 time = 1920
* CHECK dout0_7 vdout0_7ck191 = 0 time = 1920
* CHECK dout0_0 vdout0_0ck192 = 0 time = 1930
* CHECK dout0_1 vdout0_1ck192 = 0 time = 1930
* CHECK dout0_2 vdout0_2ck192 = 3.3 time = 1930
* CHECK dout0_3 vdout0_3ck192 = 3.3 time = 1930
* CHECK dout0_4 vdout0_4ck192 = 0 time = 1930
* CHECK dout0_5 vdout0_5ck192 = 3.3 time = 1930
* CHECK dout0_6 vdout0_6ck192 = 3.3 time = 1930
* CHECK dout0_7 vdout0_7ck192 = 0 time = 1930
* CHECK dout0_0 vdout0_0ck193 = 0 time = 1940
* CHECK dout0_1 vdout0_1ck193 = 0 time = 1940
* CHECK dout0_2 vdout0_2ck193 = 3.3 time = 1940
* CHECK dout0_3 vdout0_3ck193 = 3.3 time = 1940
* CHECK dout0_4 vdout0_4ck193 = 0 time = 1940
* CHECK dout0_5 vdout0_5ck193 = 3.3 time = 1940
* CHECK dout0_6 vdout0_6ck193 = 3.3 time = 1940
* CHECK dout0_7 vdout0_7ck193 = 0 time = 1940
* CHECK dout0_0 vdout0_0ck195 = 0 time = 1960
* CHECK dout0_1 vdout0_1ck195 = 0 time = 1960
* CHECK dout0_2 vdout0_2ck195 = 3.3 time = 1960
* CHECK dout0_3 vdout0_3ck195 = 3.3 time = 1960
* CHECK dout0_4 vdout0_4ck195 = 0 time = 1960
* CHECK dout0_5 vdout0_5ck195 = 3.3 time = 1960
* CHECK dout0_6 vdout0_6ck195 = 3.3 time = 1960
* CHECK dout0_7 vdout0_7ck195 = 0 time = 1960
* CHECK dout0_0 vdout0_0ck197 = 0 time = 1980
* CHECK dout0_1 vdout0_1ck197 = 3.3 time = 1980
* CHECK dout0_2 vdout0_2ck197 = 3.3 time = 1980
* CHECK dout0_3 vdout0_3ck197 = 0 time = 1980
* CHECK dout0_4 vdout0_4ck197 = 0 time = 1980
* CHECK dout0_5 vdout0_5ck197 = 0 time = 1980
* CHECK dout0_6 vdout0_6ck197 = 0 time = 1980
* CHECK dout0_7 vdout0_7ck197 = 0 time = 1980
* CHECK dout0_0 vdout0_0ck198 = 0 time = 1990
* CHECK dout0_1 vdout0_1ck198 = 3.3 time = 1990
* CHECK dout0_2 vdout0_2ck198 = 3.3 time = 1990
* CHECK dout0_3 vdout0_3ck198 = 0 time = 1990
* CHECK dout0_4 vdout0_4ck198 = 0 time = 1990
* CHECK dout0_5 vdout0_5ck198 = 0 time = 1990
* CHECK dout0_6 vdout0_6ck198 = 0 time = 1990
* CHECK dout0_7 vdout0_7ck198 = 0 time = 1990
* CHECK dout0_0 vdout0_0ck199 = 0 time = 2000
* CHECK dout0_1 vdout0_1ck199 = 0 time = 2000
* CHECK dout0_2 vdout0_2ck199 = 3.3 time = 2000
* CHECK dout0_3 vdout0_3ck199 = 3.3 time = 2000
* CHECK dout0_4 vdout0_4ck199 = 0 time = 2000
* CHECK dout0_5 vdout0_5ck199 = 3.3 time = 2000
* CHECK dout0_6 vdout0_6ck199 = 3.3 time = 2000
* CHECK dout0_7 vdout0_7ck199 = 0 time = 2000
* CHECK dout0_0 vdout0_0ck202 = 0 time = 2030
* CHECK dout0_1 vdout0_1ck202 = 0 time = 2030
* CHECK dout0_2 vdout0_2ck202 = 3.3 time = 2030
* CHECK dout0_3 vdout0_3ck202 = 3.3 time = 2030
* CHECK dout0_4 vdout0_4ck202 = 0 time = 2030
* CHECK dout0_5 vdout0_5ck202 = 3.3 time = 2030
* CHECK dout0_6 vdout0_6ck202 = 3.3 time = 2030
* CHECK dout0_7 vdout0_7ck202 = 0 time = 2030
* CHECK dout0_0 vdout0_0ck203 = 0 time = 2040
* CHECK dout0_1 vdout0_1ck203 = 0 time = 2040
* CHECK dout0_2 vdout0_2ck203 = 0 time = 2040
* CHECK dout0_3 vdout0_3ck203 = 0 time = 2040
* CHECK dout0_4 vdout0_4ck203 = 0 time = 2040
* CHECK dout0_5 vdout0_5ck203 = 0 time = 2040
* CHECK dout0_6 vdout0_6ck203 = 3.3 time = 2040
* CHECK dout0_7 vdout0_7ck203 = 3.3 time = 2040
* CHECK dout0_0 vdout0_0ck204 = 0 time = 2050
* CHECK dout0_1 vdout0_1ck204 = 0 time = 2050
* CHECK dout0_2 vdout0_2ck204 = 3.3 time = 2050
* CHECK dout0_3 vdout0_3ck204 = 3.3 time = 2050
* CHECK dout0_4 vdout0_4ck204 = 0 time = 2050
* CHECK dout0_5 vdout0_5ck204 = 3.3 time = 2050
* CHECK dout0_6 vdout0_6ck204 = 3.3 time = 2050
* CHECK dout0_7 vdout0_7ck204 = 0 time = 2050
.include /home/dareminion/proc_design/openram-mem/generated_mem/functional_meas.sp
* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
